Commit message: september

File: kuka.urdf (robot description, URDF)
Before this commit: robot iiwa14, 12 links, 11 joints
Links:
- removed link iiwa_link_ft_connection
- removed link iiwa_link_wiring
Joints:
- removed joint iiwa_joint_ft_connection
- removed joint iiwa_joint_wiring
